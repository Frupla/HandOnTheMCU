<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LCD_Demo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\SawToothAndBlinkingLED\LCD_Demo.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>LCD_Demo</project>
                <configuration>Flash Debug</configuration>
            </member>
            <member>
                <project>LCD_Demo</project>
                <configuration>SDRAM Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
