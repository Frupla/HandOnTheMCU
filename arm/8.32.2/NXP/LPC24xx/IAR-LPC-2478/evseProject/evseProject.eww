<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\evseProject.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>TouchDemo</project>
                <configuration>Flash Debug</configuration>
            </member>
            <member>
                <project>TouchDemo</project>
                <configuration>SDRAM Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
