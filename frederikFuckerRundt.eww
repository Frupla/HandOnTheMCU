<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\OneDrive\Dokumenter\IAR Embedded Workbench\arm\8.32.2\NXP\LPC24xx\IAR-LPC-2478\LCD_Demo\LCD_Demo.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>LCD_Demo</project>
                <configuration>Flash Debug</configuration>
            </member>
            <member>
                <project>LCD_Demo</project>
                <configuration>SDRAM Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
